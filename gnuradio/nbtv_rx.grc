options:
  parameters:
    generate_options: qt_gui
    id: nbtv_rx
    output_language: python
    title: nbtv_rx
  states: {}

blocks:
- name: framerate
  id: variable
  parameters:
    value: '3'
  states: {}
- name: line_pixels
  id: variable
  parameters:
    value: '48'
  states: {}
- name: lines
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: scan_rate
  id: variable
  parameters:
    value: (lines*line_pixels)*framerate
  states: {}
- name: sync_threshold
  id: variable_qtgui_range
  parameters:
    label: Horizontal Sync Threshold
    start: '-1'
    step: '0.025'
    stop: '1'
    value: '-0.75'
  states: {}
- name: vert_sync
  id: variable_qtgui_range
  parameters:
    label: Vertical Sync
    start: '0'
    step: '1'
    stop: lines
    value: '0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: sync_threshold
    type: float
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: sync_threshold
    init: '0'
    low: sync_threshold
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/cam/Desktop/GNU Radio/Narrowband TV/out.wav
    repeat: 'True'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pygame

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, lines=32, line_size=48, framerate=12.5, sync_level=0.05):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='NBTV Receive',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.lines = line_size
              self.line_size = lines
              self.framerate = framerate
              self.sync_level = sync_level

              # Scanning beam
              self.lineCounter = 0
              self.pixelCounter = 0
              self.txCounterOffset = 0
              self.frameBuf = np.zeros((self.lines*self.line_size), dtype=np.uint8)
              self.synced = False

              self.started = False

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              # Initialize display
              if(self.started == False):
                  pygame.init()
                  self.screen = pygame.display.set_mode((self.line_size*8, self.lines*8))
                  self.started = True

              input_items_orig = np.copy(input_items)
              np.rint(input_items[0]*340, out=input_items[0])
              for i in range(0, len(input_items[0])):
                  #self.frameBuf[(self.lineCounter*self.line_size)+self.pixelCounter] = input_items[0][i]
                  if(input_items_orig[0][i] <= self.sync_level):
                      self.pixelCounter = 0
                      self.lineCounter += 1
                      if(self.lineCounter >= self.lines):
                          self.lineCounter = 0
                          pygame.display.flip()
                      continue
                  
                  #  Draw the current pixel
                  for event in pygame.event.get():
                      if event.type == pygame.QUIT:
                          running = False
                  brightness = int(input_items[0][i])
                  if brightness < 0:
                      brightness = 0
                  if brightness > 255:
                      brightness = 255
                  pygame.draw.rect(self.screen, (brightness, brightness, brightness), (self.pixelCounter*8, self.lineCounter*8, 8, 8))
                  #pygame.display.flip()

                  # Move the beam along
                  self.pixelCounter += 1
                  if(self.pixelCounter >= self.line_size):
                      self.pixelCounter = 0
                      self.lineCounter += 1
                      if(self.lineCounter >= self.lines):
                          self.lineCounter = 0
                          pygame.display.flip()

              return len(input_items[0])
    framerate: framerate
    line_size: line_pixels
    lines: lines
    sync_level: sync_threshold
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '2001'
    server: 'True'
    type: float
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_1
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: scan_rate/samp_rate
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Sync Pulses
    label2: Baseband Video
    label3: Sync Threshold
    nconnections: '3'
    size: '24000'
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '2']
- [audio_source_0, '0', blocks_threshold_ff_0, '0']
- [audio_source_0, '0', blocks_throttle2_0_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0_0, '0', pfb_arb_resampler_xxx_1, '0']
- [blocks_wavfile_source_0, '0', blocks_threshold_ff_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0, '1']
- [network_tcp_source_0, '0', blocks_threshold_ff_0, '0']
- [network_tcp_source_0, '0', blocks_throttle2_0_0, '0']
- [network_tcp_source_0, '0', qtgui_time_sink_x_0, '1']
- [pfb_arb_resampler_xxx_1, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
